FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:intel-corei7-64 = " file://vm-networking.cfg"
