FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:uno-q = " file://fuse.cfg"
